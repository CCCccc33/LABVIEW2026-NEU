# Keil uVision project SLAVE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: SLAVE +hex
  c flags: Optimize=8 SizeSpeed=1
  group SLAVE
    ./: SLAVE.c
  group CRC
    ./: CRC.c
  group DS18B20
    ./: DS18B20.c
  group DHT11
    ./: DHT11_1.c DHT11_2.c
  group BH1750
    ./: BH1750.c
